# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMComplier5)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32C031xx
  c include: ..\STM32\CMSIS\Device\ST\STM32C0xx\Include;..\STM32\CMSIS\Include;..\STM32\STM32C0xx_HAL_Driver\Inc;..\User;..\Drive\Include
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x00008000
  group User
    ../User/: main.c stm32c0xx_hal_msp.c stm32c0xx_it.c
  group STM32
    ../STM32/CMSIS/Device/ST/STM32C0xx/Source/Templates/arm/: startup_stm32c031xx.s
    ../STM32/CMSIS/Device/ST/STM32C0xx/Source/Templates/: system_stm32c0xx.c
    ../STM32/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_adc.c stm32c0xx_hal_adc_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal_crc.c stm32c0xx_hal_crc_ex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_fdcan.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_hcd.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_i2s.c stm32c0xx_hal_irda.c stm32c0xx_hal_iwdg.c stm32c0xx_hal_pcd.c stm32c0xx_hal_pcd_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_rtc.c stm32c0xx_hal_rtc_ex.c stm32c0xx_hal_smartcard.c stm32c0xx_hal_smartcard_ex.c stm32c0xx_hal_smbus.c stm32c0xx_hal_smbus_ex.c stm32c0xx_hal_spi.c stm32c0xx_hal_spi_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c stm32c0xx_hal_usart.c stm32c0xx_hal_usart_ex.c stm32c0xx_hal_wwdg.c stm32c0xx_ll_adc.c stm32c0xx_ll_crc.c stm32c0xx_ll_crs.c stm32c0xx_ll_dma.c stm32c0xx_ll_exti.c stm32c0xx_ll_gpio.c stm32c0xx_ll_i2c.c stm32c0xx_ll_pwr.c stm32c0xx_ll_rcc.c stm32c0xx_ll_rtc.c stm32c0xx_ll_spi.c stm32c0xx_ll_tim.c stm32c0xx_ll_usart.c stm32c0xx_ll_usb.c stm32c0xx_ll_utils.c
